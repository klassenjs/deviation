options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: WBFMRcvrDev
    output_language: python
    title: WBFM Receiver/Deviation Meter
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Frequency (Hz)
    type: real
    value: '92.1'
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: RF Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: alpha
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1,1,1
    label: alpha
    type: real
    value: '.01'
  states: {}
- name: ramp
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,1
    label: Ramp
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.40e6
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Squelch
    start: '-70'
    step: '1'
    stop: '0'
    value: '-24'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Volume
    start: '0'
    step: '.1'
    stop: '3'
    value: '.4'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 96e3
    audio_stop: 100e3
    chan_rate: samp_rate/10
    deviation: '75000'
    gain: '1'
    tau: '0'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: alpha
    gate: 'False'
    ramp: ramp
    threshold: thresh
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 54e3
    low_cutoff_freq: 22e3
    samp_rate: samp_rate/10
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '20'
    high_cutoff_freq: '19100'
    low_cutoff_freq: '18900'
    samp_rate: samp_rate/10
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '75'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 180e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 16e3
    decim: '5'
    gain: volume
    samp_rate: samp_rate/10
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 16e3
    decim: '5'
    gain: volume
    samp_rate: samp_rate/10
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '240000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 0,0,1,2
    label1: ''
    name: Scope Plot
    size: '1024'
    srate: '240000'
    type: float
    ylabel: Deviation
    ymax: '75'
    ymin: '-75'
    yunit: KHz
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '1'
    corr0: '60'
    freq0: Freq*1e6
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '52.6e-3'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '52.6e-3'
    type: float
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', band_pass_filter_0, '0']
- [analog_fm_demod_cf_0, '0', band_pass_filter_0_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_fm_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_fm_demod_cf_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_multiply_xx_1, '0', dc_blocker_xx_0, '0']
- [blocks_sub_xx_0, '0', audio_sink_0, '1']
- [dc_blocker_xx_0, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_1, '0', blocks_add_xx_0, '0']
- [low_pass_filter_1, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_1_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_1_0, '0', blocks_sub_xx_0, '1']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [single_pole_iir_filter_xx_0, '0', low_pass_filter_1, '0']
- [single_pole_iir_filter_xx_0_0, '0', low_pass_filter_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
