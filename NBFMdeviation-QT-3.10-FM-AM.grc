options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: NBFMRcvrDevQT
    output_language: python
    title: NBFM Receiver/Deviation Meter
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Frequency (MHz)
    type: real
    value: '144.39'
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: RF Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: alpha
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1,1,1
    label: alpha
    type: real
    value: '.01'
  states: {}
- name: ramp
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,1
    label: Ramp
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.40e6
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Squelch
    start: '-70'
    step: '1'
    stop: '0'
    value: '-24'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Volume FM
    start: '0'
    step: '.1'
    stop: '3'
    value: '.4'
  states: {}
- name: volume_am
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Volume AM
    start: '0'
    step: '.1'
    stop: '3'
    value: '.4'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: '48000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '3500'
    audio_stop: '4000'
    chan_rate: '48000'
    deviation: '10000'
    gain: '1.0'
    tau: '1e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: alpha
    gate: 'False'
    ramp: ramp
    threshold: thresh
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_am
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 7.5e3
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("black", "white")
    factor1: '20'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,1,1,1
    label1: IF Signal Level
    max: '0'
    min: '-60'
    type: float
    unit1: dBfs
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 0,0,1,2
    label1: FM
    label2: AM
    name: Scope Plot
    nconnections: '2'
    size: '1024'
    srate: '48000'
    type: float
    ylabel: Deviation
    ymax: '8'
    ymin: '-8'
    yunit: KHz
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '1'
    corr0: '60'
    freq0: Freq*1e6
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '38.55e-3'
    type: float
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_am_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '1']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
